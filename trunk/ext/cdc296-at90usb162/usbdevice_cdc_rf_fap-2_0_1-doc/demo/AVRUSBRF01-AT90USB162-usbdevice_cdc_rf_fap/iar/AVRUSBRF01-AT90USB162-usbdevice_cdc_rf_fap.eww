<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AVRUSBRF01-AT90USB162-usbdevice_cdc_rf_fap.ewp</path>
  </project>
  <batchBuild/>
</workspace>


