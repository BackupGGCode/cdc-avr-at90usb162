# IAR project AVRUSBRF01-AT90USB162-usbdevice_cdc_rf_fap.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDiagSuppress: Pe111,Pe550
  ICCAVR.newCCIncludePaths: ..; ../conf; ../../../
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnkusb162s.xcl
configuration Release (AVR)
  as the first configuration, except:
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: cdc_rf_task.c fap.c FAPtoNRF_API.c FAPtoNRF_API.h main.c usb_descriptors.c usb_specific_request.c wdp_setup.h
    ../../../lib_mcu/flash/: flash_drv.s90
    ../../../lib_board/nrf24l01/: nRF_API.c
    ../../../lib_mcu/power/: power_drv.c
    ../../../modules/scheduler/: scheduler.c
    ../../../lib_mcu/spi/: spi_lib.c
    ../../../modules/usb/device_chap9/: usb_device_task.c usb_standard_request.c
    ../../../lib_mcu/usb/: usb_drv.c
    ../../../modules/usb/: usb_task.c
